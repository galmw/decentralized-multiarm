Commit message: Workin RRT Run (Dynamic)

File: assets/ur5/ur5_training.urdf (robot description, URDF)
Before this commit: robot ur5, 11 links, 10 joints
Links:
- link base: mass None -> 1
- link ee_link: mass None -> 1
- link tool0: mass None -> 1
